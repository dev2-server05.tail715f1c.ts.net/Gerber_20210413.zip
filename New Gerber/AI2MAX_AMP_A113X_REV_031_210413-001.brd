# Allegro board AI2MAX_AMP_A113X_REV_031_210413-001.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NRST_AMP2: length 69.2
  TOP w0.1: v1(36.1,61.75) 36.1,47.4 35.65,46.95 35.65,40.05 v1(35.85,39.85) 35.65,39.65 35.65,36.95 36.1,36.5 36.1,27.35 35.77,27.02 35.77,23.12 v1(36.38,22.52)
  BOTTOM w0.1: R316.2 R315.2 R338.2 45,26.45 42.85,26.45 41.4,25 39.16,25 36.69,22.52 v1(36.38,22.52)
  BOTTOM w0.2: U301.36 33.37,36.77 33.5,36.9 33.5,37.71 C304.2 34.69,38.14 34.85,38.3 34.85,39.4 35.3,39.85 v1(35.85,39.85) ; U302.36 33.37,58.72 33.5,58.85 33.5,59.67 33.92,60.09 C326.2 34.69,60.09 34.85,60.25 34.85,61.4 35.2,61.75 v1(36.1,61.75)
PDM_DCLK: length 11
  TOP w0.1: T102.1 83.2,49.05 82.25,48.1 79.35,48.1 78.65,48.8 78.36,48.8 77.72,48.16 75.23,48.16 74.9,48.49 74.36,48.49 U1.E16
PDM_DIN0: length 3.9
  TOP w0.1: T103.1 78.31,47.96 75.13,47.96 74.92,48.17 U1.E17
PDM_DIN1: length 8.3
  TOP w0.1: U1.D16 74.37,49.15 74.92,49.15 75.5,48.57 77.52,48.57 78.2,49.25 78.8,49.25 79.53,48.52 80.57,48.52 T104.1
PDM_DIN2: length 8.8
  TOP w0.1: T105.1 81.68,48.31 79.44,48.31 78.7,49.05 78.3,49.05 77.62,48.36 75.38,48.36 74.93,48.82 U1.D17
PDM_DIN3: length 5.8
  TOP w0.1: U1.C17 74.96,49.47 75.66,48.77 77.41,48.77 78.09,49.45 79.42,49.45 T106.1
POWERSTB: length 67.2
  TOP w0.1: v1(43.35,36.2) 43.15,36.4 43.15,57.55 43.25,57.65 v1(43.25,58.05) ; v1(71.85,56.95) 71.65,57.15 71.65,59.25 v1(71.25,59.65)
  TOP w0.102: v2(71.12,49.15) U1.C12
  BOTTOM w0.1: v1(43.25,58.05) 43.25,57.85 43.65,57.45 52.65,57.45 53.17,57.98 53.17,59.23 53.4,59.45 54.12,59.45 54.42,59.75 57.18,59.75 57.48,59.45 65.65,59.45 66.05,59.85 66.7,59.85 67.3,59.25 70.85,59.25 v1(71.25,59.65) ; v1(71.85,56.95) 72,56.8 72,51.22 71.43,50.65 71.43,49.46 v2(71.12,49.15)
  BOTTOM w0.3: R13.1 R12.1 42.95,35.8 v1(43.35,36.2)
PVREF: length 0.5
  TOP w0.102: v2(70.47,43.29) U1.N11
PWR_24V: length 190.1
  TOP w0.25: 30.1,3 29.45,3.65 ; 29.45,3.65 29.65,3.65 v1(29.9,3.4) 30.1,3.6 30.65,3.6 C4.1 31.3,2.95 C30.1 C3.1 38.7,2.95 v1(38.75,2.9) ; 29.45,3.65 U2.2
  TOP w0.5: C224.1 98.3,59.1 v1(98.3,59.66) v1(98.3,60.26) 98.6,60.26 ; C224.1 98.9,59.1 v1(98.9,59.66) v1(98.9,60.26) 98.6,60.26 ; C224.1 98.6,60.26 ; C224.1 C256.1 ; 31.45,46.83 v1(31.75,46.83) v1(31.75,47.43) 31.75,48.05 31.45,48.35 ; 31.45,46.83 31.45,48.35 ; 31.45,46.83 v1(31.15,46.83) v1(31.15,47.43) 31.15,48.15 C348.1 31.45,48.35 ; 31.45,24.88 v1(31.75,24.88) v1(31.75,25.48) 31.75,26.05 31.45,26.35 ; 31.45,24.88 v1(31.15,24.88) v1(31.15,25.48) 31.15,26.15 C324.1 31.45,26.35 ; 31.45,24.88 31.45,26.35 ; 98.6,49.4 98.9,49.1 v1(98.9,48.44) v1(98.9,47.84) 98.6,47.84 ; 98.6,49.4 98.3,49.1 v1(98.3,48.44) v1(98.3,47.84) 98.6,47.84 ; 98.6,49.4 C255.1 ; 98.6,49.4 98.6,47.84 ; v1(98.3,20.95) v1(98.9,20.35) ; v1(98.3,20.95) v1(97.7,20.95) ; v1(98.3,20.95) v1(97.7,21.55) ; v1(98.3,20.95) v1(98.9,20.95) ; v1(98.9,20.35) v1(98.9,20.95) ; v1(98.9,20.35) v1(98.3,20.35) ; 23.75,16.9 v1(23.75,17.2) v1(24.35,17.2) v1(24.95,17.2) v1(25.55,17.2) 25.55,16.9 ; 23.75,16.9 25.55,16.9 ; 23.75,16.9 v1(23.75,16.6) v1(24.35,16.6) v1(24.95,16.6) v1(25.55,16.6) 25.55,16.9 ; 98.6,25.9 v1(98.9,25.9) v1(98.9,26.5) 98.9,27.1 98.6,27.4 ; 98.6,25.9 98.6,27.4 ; 98.6,25.9 v1(98.3,25.9) v1(98.3,26.5) 98.3,27.1 98.6,27.4 ; 98.6,27.4 C257.1 ; v1(97.7,20.95) v1(97.7,20.35) v1(98.3,20.35) ; v1(97.7,20.95) v1(97.7,21.55) ; v1(97.7,20.95) v1(98.3,20.35) ; 31.45,57.85 31.4,57.8 31.15,58.05 v1(31.15,58.65) v1(31.15,59.25) 31.45,59.25 ; 31.45,57.85 C355.1 ; 31.45,57.85 31.75,58.15 v1(31.75,58.65) v1(31.75,59.25) 31.45,59.25 ; 31.45,57.85 31.45,59.25 ; 98.6,38.32 v1(98.3,38.32) v1(98.3,37.72) 98.3,37.1 C248.1 ; 98.6,38.32 v1(98.9,38.32) v1(98.9,37.72) 98.9,37.1 C248.1 ; 98.6,38.32 C248.1 ; v1(98.3,21.55) v1(98.9,20.95) ; v1(98.3,21.55) v1(97.7,21.55) ; v1(98.3,21.55) v1(98.9,21.55) v1(98.9,20.95) ; 31.45,48.35 C356.1 ; 31.45,35.85 31.75,36.15 v1(31.75,36.7) v1(31.75,37.3) 31.45,37.3 ; 31.45,35.85 C353.1 ; 31.45,35.85 31.45,37.3 ; 31.45,35.85 31.4,35.8 31.15,36.05 v1(31.15,36.7) v1(31.15,37.3) 31.45,37.3 ; C248.1 C258.1 ; 31.45,26.35 C354.1
  BOTTOM w0.1: R1.2 29.15,3.4 v1(29.9,3.4)
  BOTTOM w0.3: 99.17,28.47 99.18,28.48 U202.31 ; 99.17,28.47 99.17,27.99 98.96,27.78 ; 99.17,28.47 98.95,28.47 ; 99.17,35.75 99.18,35.74 U202.20 ; 99.17,35.75 98.95,35.75 ; 99.17,35.75 99.17,36.23 98.96,36.44 ; 31.09,57.37 31.37,57.65 ; 31.09,57.37 31.09,58.59 v1(31.15,58.65) ; 31.09,57.37 31.1,57.35 31.1,56.68 ; 31.09,57.37 30.88,57.16 30.88,56.68 ; 31.37,57.65 31.37,56.68 ; 31.37,57.65 31.45,57.73 ; 31.37,56.68 31.1,56.68 ; 31.37,56.68 U302.32 ; 98.95,35.75 98.95,36.42 98.96,36.44 ; 98.95,35.75 98.68,35.75 ; 31.09,35.42 30.88,35.21 30.88,34.73 ; 31.09,35.42 31.1,35.4 31.1,34.73 ; 31.09,35.42 31.09,35.47 31.37,35.75 ; 98.95,50.41 98.68,50.41 ; 98.95,50.41 98.95,49.74 98.96,49.72 ; 98.95,50.41 99.17,50.41 ; 98.68,50.41 U201.32 ; 98.68,50.41 98.68,49.5 ; 99.17,57.69 98.95,57.69 ; 99.17,57.69 99.17,58.17 98.96,58.38 ; 99.17,57.69 99.18,57.68 U201.20 ; 98.95,57.69 98.68,57.69 ; 98.95,57.69 98.95,58.36 98.96,58.38 ; 31.37,48.43 C348.1 31.45,48.35 ; 31.37,48.43 31.09,48.71 ; 31.37,48.43 31.37,49.4 ; 98.96,27.78 98.95,27.8 98.95,28.47 ; 98.96,27.78 98.96,26.56 v1(98.9,26.5) ; 98.96,27.78 98.68,27.5 ; 98.96,36.44 98.68,36.72 ; 98.96,36.44 98.96,37.66 v1(98.9,37.72) ; 30.88,56.68 30.87,56.67 U302.31 ; 30.88,56.68 31.1,56.68 ; 31.37,34.73 31.37,35.75 ; 31.37,34.73 U301.32 ; 31.37,34.73 31.1,34.73 ; 31.37,35.75 C306.1 ; 98.68,27.5 C231.1 ; 98.68,27.5 98.68,28.47 ; U201.31 99.18,50.42 99.17,50.41 ; 31.37,27.45 U301.19 ; 31.37,27.45 31.37,26.43 C324.1 ; 31.37,27.45 31.1,27.45 ; 31.09,48.71 31.1,48.73 31.1,49.4 ; 31.09,48.71 30.88,48.92 30.88,49.4 ; 31.09,48.71 31.09,47.49 v1(31.15,47.43) ; 31.1,49.4 31.37,49.4 ; 31.1,49.4 30.88,49.4 ; 31.37,49.4 U302.19 ; 98.96,58.38 98.68,58.66 ; 98.96,58.38 98.96,59.6 v1(98.9,59.66) ; 99.17,50.41 99.17,49.93 98.96,49.72 ; 98.68,36.72 98.68,35.75 ; 98.68,36.72 C248.1 ; 98.68,35.75 U202.19 ; 98.68,57.69 U201.19 ; 98.68,57.69 98.68,58.66 ; 30.88,49.4 30.87,49.41 U302.20 ; 30.88,34.73 30.87,34.72 U301.31 ; 30.88,34.73 31.1,34.73 ; 98.68,28.47 U202.32 ; 98.68,28.47 98.95,28.47 ; 30.88,27.45 30.88,26.97 31.09,26.76 31.1,26.78 31.1,27.45 ; 30.88,27.45 31.1,27.45 ; 30.88,27.45 30.87,27.46 U301.20 ; 98.96,49.72 98.9,49.72 98.68,49.5 ; 98.68,49.5 C206.1 ; 98.68,58.66 98.6,58.74
  BOTTOM w0.5: v1(31.75,47.43) v1(31.15,47.43) ; v1(31.75,47.43) v1(31.15,46.83) ; v1(31.75,47.43) 31.45,47.73 31.45,48.35 31.15,48.05 v1(31.15,47.43) ; v1(31.75,47.43) v1(31.75,46.83) v1(31.15,46.83) ; v1(31.15,47.43) v1(31.15,46.83) ; v1(31.15,24.88) v1(31.75,24.88) v1(31.75,25.48) ; v1(31.15,24.88) v1(31.75,25.48) ; v1(31.15,24.88) v1(31.15,25.48) ; 31.1,27.1 31.15,27.05 31.15,26.15 ; v1(50.9,67.6) 50.3,67.6 ; v1(50.9,67.6) v1(50.9,67) ; v1(50.9,67.6) v1(50.25,68.25) ; v1(50.9,67.6) v1(50.9,68.25) ; 50.3,67.6 50.25,67.65 v1(50.25,68.25) ; 50.3,67.6 v1(50.25,67.6) v1(50.25,67) v1(50.9,67) ; 50.3,67.6 v1(50.9,67) ; v1(82.8,66.3) v1(83.4,65.7) ; v1(82.8,66.3) v1(82.8,65.7) ; v1(82.8,66.3) v1(82.8,66.9) ; v1(83.4,65.7) v1(84,65.1) ; v1(83.4,65.7) v1(83.4,65.1) ; v1(83.4,65.7) v1(83.4,66.3) ; v1(98.9,59.66) 98.9,59.04 98.6,58.74 C224.1 98.6,59.36 v1(98.3,59.66) ; v1(98.9,59.66) v1(98.9,60.26) ; v1(98.9,59.66) v1(98.3,59.66) ; v1(31.75,58.65) 31.45,58.35 31.45,57.73 C331.1 31.15,58.03 v1(31.15,58.65) ; v1(31.75,58.65) v1(31.75,59.25) v1(31.15,59.25) ; v1(31.75,58.65) v1(31.15,58.65) ; v1(31.75,58.65) v1(31.15,59.25) ; v1(98.3,59.66) v1(98.9,60.26) ; v1(98.3,59.66) v1(98.3,60.26) v1(98.9,60.26) ; 50.3,68.85 v1(50.25,68.85) v1(50.25,68.25) ; 50.3,68.85 v1(50.9,68.85) v1(50.9,68.25) ; 50.3,68.85 v1(50.9,68.25) ; v1(98.9,38.32) v1(98.3,38.32) v1(98.3,37.72) ; v1(98.9,38.32) v1(98.3,37.72) ; v1(98.9,38.32) v1(98.9,37.72) ; v1(98.3,37.72) v1(98.9,37.72) ; v1(98.3,37.72) 98.6,37.42 C248.1 98.9,37.1 v1(98.9,37.72) ; v1(83.4,65.1) v1(82.8,65.1) v1(82.8,65.7) ; v1(83.4,65.1) v1(84,65.1) ; v1(83.4,65.1) v1(82.8,65.7) ; 31.15,36.03 C306.1 31.4,36.35 v1(31.75,36.7) ; 31.15,36.03 v1(31.15,36.7) ; 31.15,36.03 31.15,34.78 31.1,34.73 ; v1(83.4,66.9) v1(83.4,66.3) ; v1(83.4,66.9) v1(82.8,67.5) ; v1(83.4,66.9) v1(84,66.3) ; v1(83.4,66.9) v1(83.4,67.5) ; v1(83.4,66.3) v1(82.8,66.9) ; v1(83.4,66.3) v1(84,65.7) ; v1(31.75,25.48) 31.45,25.78 31.45,26.35 C324.1 31.15,26.15 ; v1(31.75,25.48) v1(31.15,25.48) ; v1(31.75,36.7) v1(31.15,37.3) ; v1(31.75,36.7) v1(31.75,37.3) v1(31.15,37.3) ; v1(31.75,36.7) v1(31.15,36.7) ; v1(82.8,67.5) v1(82.8,66.9) ; v1(82.8,67.5) v1(83.4,67.5) ; v1(31.15,58.65) v1(31.15,59.25) ; v1(31.15,37.3) v1(31.15,36.7) ; 31.15,26.15 v1(31.15,25.48) ; v1(98.9,25.9) v1(98.3,25.9) v1(98.3,26.5) ; v1(98.9,25.9) v1(98.3,26.5) ; v1(98.9,25.9) v1(98.9,26.5) ; v1(84,65.1) v1(84,65.7) ; v1(98.3,48.44) v1(98.9,47.84) ; v1(98.3,48.44) v1(98.9,48.44) ; v1(98.3,48.44) v1(98.3,47.84) v1(98.9,47.84) ; v1(98.3,48.44) 98.6,48.74 C206.1 ; v1(98.9,47.84) v1(98.9,48.44) ; v1(84,66.3) v1(84,66.9) ; v1(84,66.3) v1(84,65.7) ; v1(84,66.9) v1(83.4,67.5) ; v1(84,66.9) v1(84,67.5) v1(83.4,67.5) ; v1(98.3,26.5) 98.6,26.8 C231.1 98.9,27.12 v1(98.9,26.5) ; v1(98.3,26.5) v1(98.9,26.5) ; v1(98.9,48.44) 98.9,49.9 98.95,49.95
  vias: v1(38.75,3.5) v1(38.75,2.3) v1(39.35,3.5) v1(39.35,2.9) v1(39.35,2.3) v1(39.95,3.5) v1(39.95,2.9) v1(39.95,2.3) v1(66.45,5.65) v1(66.45,5.05) v1(66.45,4.45) v1(67.05,5.65) v1(67.05,5.05) v1(67.05,4.45) v1(67.65,5.65) v1(67.65,5.05) v1(67.65,4.45) v1(81.15,13.15) v1(81.15,12.55) v1(81.15,11.95) v1(81.15,11.35) v1(81.75,13.15) v1(81.75,12.55) v1(81.75,11.95) v1(81.75,11.35) v1(82.35,13.15) v1(82.35,12.55) v1(82.35,11.95) v1(82.35,11.35)
RMII_MDC: length 13.2
  TOP w0.1: U1.A11 70.79,50.91 70.46,51.25 70.46,55.05 71.25,55.84 71.25,56.5 70.97,56.77 70.38,56.77 70.2,56.95 70.2,59.95 70.8,60.55 71.3,60.55 v1(71.7,60.95)
  BOTTOM w0.4: v1(71.7,60.95) 72.53,60.95 T322.1
RMII_MDIO: length 15.5
  TOP w0.1: U1.A8 68.84,51.17 68.75,51.26 68.75,59.15 69.35,59.75 69.35,61.25 70.4,62.3 v1(72.4,62.3)
  BOTTOM w0.4: T323.1 72.4,63.36 v1(72.4,62.3)
RMII_RXCLK: length 15.2
  TOP w0.1: U1.B7 67.86,50.45 67.86,50.9 68,51.04 68,53.3 67.51,53.8 67.51,60.36 68.28,61.12 v1(68.28,62.48)
  BOTTOM w0.1: 69.3,63.5 v1(68.28,62.48)
  BOTTOM w0.4: T325.1 69.3,63.5
RMII_RXD0: length 17
  TOP w0.1: U1.B8 68.51,50.45 68.51,59.21 69.15,59.85 69.15,61.85 69.55,62.25 v1(69.55,62.45)
  BOTTOM w0.1: v1(69.55,62.45) 69.15,62.05 67.5,62.05 67,62.55 67,63.04
  BOTTOM w0.4: T327.1 67,63.04
RMII_RXD1: length 12.6
  TOP w0.1: v1(65.9,60.95) 66.75,60.1 66.75,53.95 67.72,52.97 67.72,51.12 67.54,50.94 U1.A6
  BOTTOM w0.4: v1(65.9,60.95) 65.91,60.96 T326.1
RMII_RXDV: length 11.3
  TOP w0.1: v1(68.75,60.25) 68.75,59.8 68.27,59.32 68.27,50.85 U1.A7
  BOTTOM w0.4: T324.1 69.46,60.96 v1(68.75,60.25)
RMII_TXD0: length 17.6
  TOP w0.1: U1.A10 70.14,50.92 69.99,51.07 69.99,60.04 v1(70.9,60.95)
  BOTTOM w0.1: 65.39,60.49 67.01,60.49 67.65,59.85 69.95,59.85 70.9,60.8 v1(70.9,60.95)
  BOTTOM w0.4: T328.1 65.39,60.49
RMII_TXD1: length 24.1
  TOP w0.1: U1.C9 69.49,49.47 69.82,49.8 69.82,49.81 69.82,50.88 69.75,50.95 69.75,60.6 70.5,61.35 71.3,61.35 v1(71.7,61.75)
  BOTTOM w0.1: v1(71.7,61.75) 71.3,61.35 70.75,61.35 70.45,61.65 66.7,61.65 66.35,62 63.88,62 63.22,62.66
  BOTTOM w0.4: T331.1 63.22,62.66
RMII_TXEN: length 20.2
  TOP w0.1: U1.B9 69.16,50.45 69.16,51.23 68.98,51.41 68.98,59.08 69.55,59.65 69.55,61 70.3,61.75 v1(70.9,61.75)
  BOTTOM w0.1: v1(70.9,61.75) 70.8,61.85 66.85,61.85 66.45,62.25 65.3,62.25 64.92,62.63
  BOTTOM w0.4: T329.1 64.92,62.63
SCL: length 8.3
  BOTTOM w0.1: J813.8 90.18,8.92 88.7,10.4 87.45,10.4 86.95,10.9 86.95,13.3 87.4,13.75 UNK5R66.1
SCL_AMP1: length 66.1
  TOP w0.1: v1(92.45,37.05) 92.8,37.4 92.8,47.6 92.5,47.9 92.5,57.8 91.85,58.45 v1(91.85,59.05)
  BOTTOM w0.1: R211.2 58.35,57.75 59.45,58.85 70.9,58.85 71.1,58.65 72.27,58.65 72.97,59.35 73.55,59.35 74.1,58.8 79.3,58.8 79.5,58.6 84.75,58.6 R238.2 85.65,58.6 91.4,58.6 v1(91.85,59.05)
  BOTTOM w0.2: U201.11 94.68,57.2 93.9,57.2 93.65,57.45 93.65,58.43 C222.2 93.57,58.48 93,59.05 v1(91.85,59.05) ; U202.11 94.68,35.22 94.55,35.35 93.9,35.35 93.7,35.55 C246.2 93.18,37.05 v1(92.45,37.05)
SCL_AMP2: length 59
  TOP w0.1: v1(37.6,26.15) 37.75,26.3 37.75,37 37.35,37.4 37.35,38.95 37.75,39.35 37.75,48.2 v1(37.55,48.4) 37.7,48.55 37.7,56.4 37.5,56.6 37.5,57 v1(37.9,57.4) ; R309.2 v1(54.7,57.7)
  BOTTOM w0.1: v1(37.9,57.4) 38.3,57 38.75,57 39.9,55.85 42.35,55.85 43.15,56.65 53.65,56.65 v1(54.7,57.7) R311.2 ; v1(37.55,48.4) 36.56,48.4 C346.2 36.35,49.48 35.98,49.85 35.37,49.85 U302.11
  BOTTOM w0.2: U301.11 35.37,27.95 35.9,27.95 36.35,27.5 C322.2 37.09,26.66 v1(37.6,26.15)
SDA: length 5.2
  BOTTOM w0.1: UNK5R65.1 87.4,10.85 87.65,10.6 88.8,10.6 90.68,8.72 J813.7
SDA_AMP1: length 65.7
  TOP w0.1: v1(91.85,35.95) 91.85,37.05 92.6,37.8 92.6,47.5 92.3,47.8 92.3,57.44 v1(91.85,57.89)
  BOTTOM w0.1: v1(91.85,57.89) 91.34,58.4 85.65,58.4 R239.2 84.75,58.4 79.4,58.4 79.2,58.6 74,58.6 73.45,59.15 73.05,59.15 72.35,58.45 71,58.45 70.8,58.65 59.55,58.65 59,58.1 59,57.25 R212.2
  BOTTOM w0.2: U202.10 92.52,34.36 C241.2 91.85,34.91 v1(91.85,35.95) ; U201.10 92.52,56.3 C217.2 91.85,56.85 v1(91.85,57.89)
SDA_AMP2: length 56.3
  TOP w0.1: v1(38.2,27.25) 37.95,27.5 37.95,37.1 37.55,37.5 37.55,38.85 37.95,39.25 37.95,49 v1(38.15,49.2) 37.9,49.45 v1(37.9,56.8) ; v1(54.7,56.6) R310.2
  BOTTOM w0.1: v1(38.15,49.2) 38.15,50.28 C341.2 37.54,50.79 U302.10 ; R312.2 v1(54.7,56.6) 54.55,56.45 43.25,56.45 42.45,55.65 39.8,55.65 38.65,56.8 v1(37.9,56.8)
  BOTTOM w0.2: v1(38.2,27.25) 38.2,28.29 C317.2 37.53,28.84 U301.10
SPDIF_IN: length 7.2
  TOP w0.102: v2(73.07,48.5) U1.E14
  BOTTOM w0.1: v2(73.07,48.5) 73.35,48.78 73.93,48.78 74.3,49.15 76.45,49.15 76.98,49.68 78.93,49.68 T107.1
SPDIF_OUT: length 3.1
  TOP w0.102: T108.1 75.12,49.63 74.95,49.8 74.37,49.8 U1.C16
SPI_CLK: length 33.2
  TOP w0.102: v1(59.03,60.35) 59.03,54.66 v1(59.33,54.36) ; v2(67.86,49.8) 67.88,49.8 U1.C6
  BOTTOM w0.1: v2(67.86,49.8) 67.86,49.9 67.71,50.05 67.71,51.84 65.19,54.36 v1(59.33,54.36) ; 45.3,60.8 45.75,60.35 v1(59.03,60.35)
  BOTTOM w0.3: UNK2T16.1 45.3,60.8
SPI_MISO: length 33.4
  TOP w0.1: 58.01,59.54 58.01,60.39 v1(57.45,60.95)
  TOP w0.102: U1.D6 67.21,49.15 v2(67.21,49.15) ; v1(58.55,53.55) 58.01,54.09 58.01,59.54
  BOTTOM w0.1: v2(67.21,49.15) 67.51,49.44 67.51,51.53 65.64,53.39 59.96,53.39 59.8,53.55 v1(58.55,53.55) ; 47.7,62.8 47.7,61.1 48.05,60.75 57.25,60.75 v1(57.45,60.95)
  BOTTOM w0.3: UNK2T19.1 47.7,62.8
SPI_MOSI: length 31.7
  TOP w0.1: 58.45,53.95 58.7,53.95 59.1,53.55 v1(59.1,53.15)
  TOP w0.102: v1(58.05,60.95) 58.21,60.79 58.21,54.19 58.45,53.95 ; v2(67.15,49.74) 67.14,49.75 67.03,49.75 66.89,49.61 U1.C5
  BOTTOM w0.1: v1(58.05,60.95) 57.65,60.55 47.55,60.55 47.21,60.89 ; v2(67.15,49.74) 67.31,49.89 67.31,51.41 65.57,53.15 v1(59.1,53.15)
  BOTTOM w0.3: UNK2T18.1 47.21,60.89
SPI_SS0: length 28.1
  TOP w0.1: U1.C1 64.14,49.47 63.29,50.32 63.29,50.9 61.87,52.33 61.87,53.14 61.1,53.91 61.1,57.1 60.76,57.44 60.76,62.43 60.2,62.99 v1(60.2,63.1)
  BOTTOM w0.1: 49.3,62.4 49.6,62.7 58.4,62.7 59.2,63.5 59.8,63.5 v1(60.2,63.1)
  BOTTOM w0.3: UNK2T20.1 49.3,62.4
SPK_I2C_SCK: length 24.1
  TOP w0.1: U1.E3 65.27,48.49 64.18,48.49 62.68,49.99 62.68,50.6 61.66,51.62 61.03,51.62 60.4,52.25 57.85,52.25 57.05,53.05 57.05,55.8 56.45,56.4 56.45,57.3 v1(56.85,57.7) 56.85,59.3 56.35,59.8 56.35,61 v1(55.45,61.9)
  BOTTOM w0.1: R211.1 v1(56.85,57.7) R311.1 UNK2R18.2
  BOTTOM w0.3: UNK2T26.1 55.15,61.6 v1(55.45,61.9)
SPK_I2C_SDA: length 23.4
  TOP w0.1: U1.D1 64.16,48.82 62.89,50.09 62.89,50.7 61.75,51.84 61.11,51.84 60.5,52.45 57.95,52.45 57.27,53.14 57.27,56.18 v1(56.85,56.6) 57.25,57 57.25,59.2 56.55,59.9 56.55,62.65 v1(57.2,63.3)
  BOTTOM w0.1: R212.1 v1(56.85,56.6) R312.1 UNK2R19.2
  BOTTOM w0.3: v1(57.2,63.3) 56.8,63.3 UNK2T27.1
SPK_RST: length 5.8
  TOP w0.102: UNK2R23.1 79,54.56 v2(79.12,54.68) ; v2(77.36,56.95) 77.36,57.76 78.03,58.42 UNK2T8.1
  BOTTOM w0.1: v2(77.36,56.95) 79.12,55.2 v2(79.12,54.68)
STANDBY_A113X: length 66.4
  TOP w0.1: v1(73.25,56.95) v2(73.25,58.78) ; v1(88.4,54.5) 88.6,54.3 88.6,33.15 89.8,31.95 89.8,20.95 v1(90.25,20.5)
  TOP w0.102: v2(71.8,49.76) 71.95,49.76 72.09,49.62 U1.C13
  BOTTOM w0.1: v1(90.25,20.5) 90.65,20.1 90.65,19.65 90.3,19.3 89.25,19.3 88.5,18.55 UNK5R77.2 ; v1(73.25,56.95) 73.2,56.95 72.23,55.98 72.23,50.99 71.8,50.56 v2(71.8,49.76) ; v1(88.4,54.5) 87.3,55.6 80.9,55.6 78.1,58.4 73.63,58.4 v2(73.25,58.78)
SYS_LED: length 20.7
  TOP w0.1: v1(71.2,63.5) UNK2R8.2
  TOP w0.102: v1(76.25,62) 76.25,61.62 77.37,60.5 77.37,58.37 76.95,57.96 76.95,56.33 75.38,54.76 75.38,53.65 73.45,51.72 73.45,50.83 U1.A15
  BOTTOM w0.3: v1(71.2,63.5) 72.05,64.35 72.95,64.35 75,62.3 75.95,62.3 v1(76.25,62)
USB_PWR_EN: length 16.5
  TOP w0.102: UNK2T7.1 76.7,60.1 76.14,59.54 76.14,57.66 v2(76.3,57.51) ; U1.C11 70.93,49.47 71.05,49.59 71.05,49.74 v2(71.06,49.75)
  BOTTOM w0.1: v2(76.3,57.51) 76.13,57.67 71.67,57.67 71.47,57.48 71.47,55.83 71.15,55.5 71.15,55.15 71.45,54.85 71.45,51.87 71.06,51.49 v2(71.06,49.75)
USB_TXRTUNE: length 5.4
  TOP w0.102: v2(73.07,45.24) 73.07,45.25 U1.J15
  BOTTOM w0.1: UNK5R64.1 76.35,45.39 76.35,45.54 76.17,45.72 75.46,45.72 75.31,45.57 73.39,45.57 v2(73.07,45.24)
USBOTG_A_DM: length 45.2
  TOP w0.1: U1.L16 74.27,44.27 74.59,43.95 75.46,43.95 75.89,43.52 76.22,43.52 77.38,42.37 77.38,41.06 78.88,39.56 78.88,37.46 79.65,36.68 79.65,22.7 84.3,18.05 86.66,18.05 88.14,16.57 90.92,16.57 v1(91.15,16.35) 91.6,16.35 UNK5R84.2
  BOTTOM w0.1: v1(91.15,16.35) 92.05,15.45 UNK5D12.1 92.05,14.15 91.95,14.05 91.35,14.05 91.25,13.95 91.25,13.55 91.65,13.15 91.65,12.55 92.05,12.15 UNK5R71.2
USBOTG_A_DP: length 45.3
  TOP w0.1: U1.L17 74.78,44.17 75.56,44.17 75.98,43.75 76.32,43.75 77.6,42.47 77.6,41.15 79.1,39.65 79.1,37.55 79.88,36.77 79.88,22.79 84.39,18.27 86.76,18.27 88.23,16.8 90.85,16.8 v1(91.15,17.1) 91.55,17.1 UNK5R85.2
  BOTTOM w0.1: UNK5R72.2 91.05,12.15 91.42,12.52 91.42,13.06 91.03,13.46 91.03,13.97 90.95,14.05 90.35,14.05 90.25,14.15 UNK5D11.1 90.25,14.55 90.7,15 90.7,16.65 v1(91.15,17.1)
USBOTG_A_ID: length 39.4
  TOP w0.1: U1.K17 74.87,44.92 75.11,44.68 75.79,44.68 76.2,44.27 79.38,44.27 79.85,43.8 79.85,43.15 80.45,42.55 UNK5C3.2 UNK5R78.1 v1(80.65,40.7) 82.35,39 82.35,30.1 81.6,29.35 81.6,22.6 84.85,19.35 87.3,19.35 v1(88.05,18.6) 88.45,18.2 UNK5R83.2
  BOTTOM w0.1: v1(88.05,18.6) 87.4,17.95 UNK5R76.2
  BOTTOM w0.3: v1(80.65,40.7) 80.9,40.7 UNK5R20.2
USBOTG_A_VBUS: length 7
  TOP w0.1: UNK5C11.2 78.7,44.05 76.07,44.05 75.67,44.44 75.01,44.44 74.85,44.6 74.36,44.6 U1.K16
  TOP w0.3: UNK5R5.2 UNK5C11.2
WPN: length 3.3
  TOP w0.1: v1(53.65,30.2) 53.64,30.21 UNK4U5.19
  BOTTOM w0.1: v1(53.65,30.2) UNK4C9.2 UNK4R4.2
N21450221: length 2.7
  BOTTOM w0.3: R13.2 C23.1 40.7,32.35 Q1.1
N21455517: length 0.8
  TOP w0.3: U1.F13 v2(71.77,47.2)
  BOTTOM w0.2: UNK2R27.1 71.55,46.98 v2(71.77,47.2)
N21455804: length 4.4
  TOP w0.102: v2(73.64,48.43) 73.63,48.44 73.5,48.44 73.39,48.33 U1.E15
  BOTTOM w0.3: v2(73.64,48.43) 74.03,48.43 74.35,48.75 77,48.75 UNK2R29.1
N21455846: length 2.7
  TOP w0.1: UNK2R12.2 66.05,61.95 UNK2Q1.3
N21455854: length 1.8
  TOP w0.1: UNK2R12.1 62.6,62.85 UNK2D7.2
N21456019: length 6
  TOP w0.102: v2(70.47,49.15) 70.48,49.15 U1.D11
  BOTTOM w0.1: v2(70.47,49.15) 70.32,49.15 70.1,49.36 70.1,50.07 70.43,50.4 70.43,51.6 69.74,52.29 69.74,53.44 UNK2R22.2
N21456060: length 7.4
  TOP w0.127: U1.B16 74.22,50.12 74.55,50.45 74.88,50.45 74.9,50.47
  TOP w0.2: UNK2Y2.1 79.64,50.4 78.4,50.4 77.86,50.94 UNK2C3.2 77.78,51.06 UNK2R5.1 76.09,50.47 74.9,50.47
N21456068: length 4.4
  TOP w0.2: UNK2R10.2 76.98,53.21 76.02,52.25 76.02,51.14 75.73,50.85 74.77,50.85 U1.A17
N21456125: length 7.6
  TOP w0.2: UNK2R5.2 76.84,52.12 UNK2C9.2 78.35,52.61 UNK2R10.1 79.02,53.21 79.76,53.95 81.67,53.95 UNK2Y2.3
N21456352: length 6.8
  TOP w0.1: UNK2CON1.4 66.46,69.11 UNK2R1.1
N21456391: length 6.7
  TOP w0.1: UNK2CON1.2 64.2,71.5 65.34,70.36 UNK2R16.1
N21464427: length 1
  TOP w0.102: v2(69.1,43.23) 69.1,43.23 U1.N8
  BOTTOM w0.102: v2(69.1,43.23) 69.34,43.23 UNK3R6.2
N21467240: length 4.7
  TOP w0.102: UNK4R15.2 63.07,42.97 U1.N1
N21467264: length 5.2
  TOP w0.102: UNK4R18.2 61.39,41.6 63.09,43.29 64.61,43.29 U1.M2
N21467467: length 2.7
  TOP w0.102: U1.L1 64.19,44.17 64.19,44.16 62.9,44.16 62.53,43.79 UNK4R11.2
N21467589: length 3.7
  TOP w0.1: UNK4R19.2 62.2,49.05 63.39,47.86 64.45,47.86 64.79,47.52 U1.F2
N21467627: length 5.5
  TOP w0.1: UNK4R20.2 59.86,49.05 60.45,48.47 62.28,48.47 63.14,47.6 64.21,47.6 U1.F1
N21467647: length 2.8
  TOP w0.1: UNK4R21.2 62.4,47.83 63.36,46.87 U1.G1
N21467665: length 6.2
  TOP w0.1: U1.G2 64.72,46.87 64.38,46.54 62.99,46.54 62.28,47.25 60.45,47.25 59.86,47.83 UNK4R22.2
N21467682: length 3.5
  TOP w0.1: U1.H2 64.62,45.9 63.93,45.9 63.5,46.33 62.12,46.33 UNK4R23.2
N21467705: length 5.3
  TOP w0.1: UNK4R24.2 59.94,46.61 60.52,46.03 63.19,46.03 63.65,45.57 U1.J1
N21467734: length 3.3
  TOP w0.1: UNK4R25.2 61.84,45.39 62.81,45.39 62.94,45.27 64.64,45.27 U1.J2
N21467764: length 5.1
  TOP w0.1: UNK4R26.2 59.88,44.91 62.58,44.91 62.59,44.92 U1.K1
N21467829: length 7.5
  TOP w0.1: U1.M3 65.59,43.62 v2(65.26,43.94)
  BOTTOM w0.102: UNK4T25.1 59.9,41.1 60.5,41.1 61.2,41.8 61.9,41.8 63.21,43.11 63.96,43.11 64.79,43.94 v2(65.26,43.94)
N21468142: length 71.1
  TOP w0.1: UNK4K2.4 14.7,13.82 14.7,16.06 UNK4K2.2 15.93,18.75 18.05,18.75 v1(18.3,19) ; v1(43.75,52.65) 43.55,52.45 43.55,36.9 44,36.45 44,34.25 43.35,33.6 43.35,27.85 43.55,27.65 44.15,27.65 44.65,27.15 v1(44.65,27.05) ; UNK4R10.1 46.08,54 v1(45.95,54)
  BOTTOM w0.1: v1(43.75,52.65) 43.75,52.8 44.95,54 v1(45.95,54) ; v1(44.65,27.05) 44.25,26.65 42.55,26.65 41.1,25.2 39.05,25.2 36.8,22.95 35.55,22.95 35.15,22.55 35.15,21.15 32.55,18.55 18.75,18.55 v1(18.3,19)
N21476089: length 7.5
  TOP w0.1: R101.1 80.65,43.85 79.51,44.99 75.17,44.99 74.93,45.23 74.38,45.23 U1.J16
N21476146: length 7
  TOP w0.102: R102.1 81.38,46.03 75.69,46.03 75.5,46.22 U1.H17
N21492341: length 4.6
  BOTTOM w0.2: R54.2 R337.1 C65.2 55.82,9.78 U51.4
N21492347: length 2
  BOTTOM w0.5: 59.1,11.82 59.1,12.59 C53.1
N21492451: length 4.8
  BOTTOM w0.2: U51.3 C63.1 R51.1 R55.1 R59.2
N21492734: length 2
  BOTTOM w0.2: C66.2 R56.1 R55.2
N21494202: length 4.7
  BOTTOM w0.5: R334.2 R335.2 C78.1 U54.1
N21494218: length 3.6
  BOTTOM w0.1: R331.1 R336.2 U54.3
N21499562: length 4
  TOP w0.5: 46.7,15.41 46.75,15.36 C59.2 46.75,12.67 47.6,11.82
N21499612: length 2.1
  TOP w0.3: U52.4 49.1,9.78 R52.1
N21499616: length 2
  TOP w0.5: 45,11.82 45,12.59 C59.1
N21499652: length 5.3
  TOP w0.2: U52.3 45.2,9.57 R53.1 C64.1 R57.1 R60.2
N21499757: length 2.1
  TOP w0.2: C67.2 48.25,6.95 R57.2 R58.1
N21500929: length 4
  TOP w0.5: 58.3,11.82 57.45,12.67 C70.2 57.45,15.36 57.4,15.41
N21500979: length 3.2
  TOP w0.2: R62.2 C75.2 59.78,9.78 U53.4
N21500983: length 2
  TOP w0.5: C70.1 56.55,12.67 55.7,11.82
N21501019: length 3.7
  TOP w0.2: U53.3 C74.1 R61.1 R63.2
N21504673: length 1.5
  TOP w0.25: U2.5 27.25,5.05 C5.1
N21504675: length 5
  TOP w0.25: U2.3 28.55,4.15 28.35,4.35 28.35,5.8 C5.2 28.15,8 L1.1
N21504709: length 2
  TOP w0.25: U2.8 25.9,3.15 R20.1
N21504737: length 3.5
  TOP w0.25: R10.1 C10.1 R11.2 R20.2
N21506141: length 6.5
  BOTTOM w0.2: C20.2 44,8.75 45.02,9.78 U3.4 ; C20.2 44.05,7.75 R7.2 ; C20.2 R6.1 42.95,7.75 R19.1
N21506145: length 2
  BOTTOM w0.5: 48.6,11.82 48.6,12.59 C15.1
N21506181: length 3.7
  BOTTOM w0.2: U3.3 C19.1 R8.1 R9.2
N21534101: length 1.4
  TOP w0.1: UNK3U1.L8 69.35,27.14 v2(69.75,27.54)
  BOTTOM w0.102: UNK3R10.2 69.92,27.37 v2(69.75,27.54)
N21597998: length 1.7
  TOP w0.1: UNK2Q1.1 UNK2R8.1
N21601268: length 7.1
  TOP w0.102: UNK2R23.2 77.21,54.56 74.37,51.72 74.37,50.6 74.21,50.45 73.88,50.45 73.71,50.27 73.71,49.79 U1.C15
N21714583: length 39.7
  TOP w0.4: L201.1 L211.1
  TOP w0.5: 101.95,47.55 v1(101.95,45.99) v1(101.95,45.39) 101.65,45.39 ; 101.95,47.55 103,48.6 ; 101.95,47.55 101.65,47.25 ; 101.65,45.39 101.65,47.25 ; 101.65,45.39 v1(101.35,45.39) v1(101.35,45.99) 101.35,46.95 101.65,47.25
  BOTTOM w0.3: U201.33 98.18,50.73 97.95,50.5 97.95,49.01 97.68,48.74 C202.2 ; C210.1 101.78,51.8 U201.30
  BOTTOM w0.5: 101.77,47.75 101.65,47.63 ; 101.77,47.75 101.95,47.57 ; 101.77,47.75 R203.1 ; 101.65,47.63 101.65,45.39 ; 101.65,47.63 101.06,47.04 ; C202.2 97.34,47.26 R202.2 97.85,46.75 98.1,46.75 ; 101.65,45.39 v1(101.95,45.39) v1(101.95,45.99) ; 101.65,45.39 v1(101.35,45.39) v1(101.35,45.99) ; v1(101.95,45.99) 101.95,47.57 ; v1(101.95,45.99) v1(101.35,45.99) ; v1(101.35,45.99) 101.35,46.35 ; 101.35,46.35 101.35,46.75 101.06,47.04 ; 101.35,46.35 100.95,46.75 98.1,46.75 ; 98.1,46.75 97.95,46.9 98.09,47.04 101.06,47.04 ; R203.1 101.77,51.73 C210.1 ; R203.1 101.95,49.6 101.95,47.57
N21714609: length 5.8
  BOTTOM w0.2: U201.38 95.68,50.68 95.4,50.4 95.4,48.1 94.3,47 C251.2 R227.2
N21714673: length 1.5
  BOTTOM w0.5: C203.2 R202.1
N21714680: length 1.6
  BOTTOM w0.3: U201.35 97.18,49.8 C202.1
N21714717: length 1.5
  BOTTOM w0.2: U201.37 96.18,49.7 R201.1
N21714779: length 1.3
  BOTTOM w0.5: R203.2 C207.2
N21714803: length 1.6
  BOTTOM w0.3: C208.2 92.59,52.3 U201.2
N21714864: length 37.7
  TOP w0.4: L211.2 L201.2
  TOP w0.5: 111,53.45 111,50 ; 111,53.45 v1(110.7,53.45) v1(110.7,52.85) 110.7,50.3 111,50 ; 111,53.45 v1(111.3,53.45) v1(111.3,52.85) 111.3,49.7 ; 111,50 111.3,49.7 ; 111.3,49.7 112.4,48.6
  BOTTOM w0.5: 109.4,52.2 C213.1 109.45,53.45
  BOTTOM w2: J803.1 117.8,33.3 111.35,39.75 111.35,47.95 110.3,49
N21714950: length 2
  BOTTOM w0.3: U201.28 101.68,52.8 C210.2
N21714966: length 3.4
  BOTTOM w0.3: C211.1 102.88,53.3 U201.27
N21715014: length 1.7
  BOTTOM w0.3: U201.6 92.4,54.3 C218.1
N21715038: length 3.4
  BOTTOM w0.3: C214.1 103.14,55.06 102.88,54.8 U201.24
N21715052: length 55.3
  TOP w0.5: 111,54.75 v1(110.7,54.75) v1(110.7,55.35) 110.7,57.9 111,58.2 ; 111,54.75 111,58.2 ; 111,54.75 v1(111.3,54.75) v1(111.3,55.35) 111.3,58.5 ; 111.3,58.5 112.4,59.6 ; 111.3,58.5 111,58.2
  BOTTOM w0.5: R205.1 110.7,55.9 v1(110.7,55.35) v1(110.7,54.75) ; R205.1 C216.2 C213.2 109.45,54.75 v1(110.7,54.75) ; R205.1 111.5,56 ; 111.5,56 112.88,56 D202.1 ; 111.5,56 111.3,55.8 v1(111.3,55.35) v1(111.3,54.75) v1(110.7,54.75)
  BOTTOM w2: 112.2,55.5 113.65,54.05 113.65,40.65 120.45,33.85 120.45,29.45 119.5,28.5 J803.2
N21715056: length 2
  BOTTOM w0.3: C215.2 101.68,55.3 U201.23
N21715058: length 45
  TOP w0.4: L202.1 L212.1
  TOP w0.5: 101.95,60.65 v1(101.95,62.21) v1(101.95,62.81) 101.65,62.81 ; 101.95,60.65 103,59.6 ; 101.95,60.65 101.65,60.95 ; 101.65,60.95 101.35,61.25 v1(101.35,62.21) v1(101.35,62.81) 101.65,62.81 ; 101.65,60.95 101.65,62.81
  BOTTOM w0.3: C215.1 101.78,56.3 U201.21 ; U201.18 98.18,57.37 97.95,57.6 97.95,59.09 97.66,59.38 C220.1
  BOTTOM w0.5: 101.35,61.8 101.35,61.35 101.06,61.06 ; 101.35,61.8 v1(101.35,62.21) ; 101.35,61.8 R208.1 ; C215.1 101.77,56.37 R206.2 ; 100.97,62.43 v1(101.35,62.81) ; 100.97,62.43 100.97,61.55 100.77,61.35 ; 100.97,62.43 100.79,62.25 98.15,62.25 R208.1 ; v1(101.35,62.81) 101.65,62.81 ; v1(101.35,62.81) v1(101.35,62.21) ; v1(101.95,62.21) v1(101.95,62.81) 101.65,62.81 ; v1(101.95,62.21) v1(101.35,62.21) ; v1(101.95,62.21) 101.95,60.53 ; C220.1 97.34,60.99 R208.1 ; 101.65,60.47 101.77,60.35 ; 101.65,60.47 101.06,61.06 ; 101.65,60.47 101.65,62.81 ; 101.77,60.35 R206.2 ; 101.77,60.35 101.95,60.53 ; R206.2 101.95,58.5 101.95,60.53 ; 100.77,61.35 98.6,61.35 R208.1 ; 100.77,61.35 101.06,61.06
N21715192: length 1.3
  BOTTOM w0.5: R206.1 C219.2
N21715198: length 4.2
  BOTTOM w0.2: U201.13 95.68,57.96 94.5,59.14 94.5,60.05 T201.1
N21715200: length 1.6
  BOTTOM w0.2: U201.14 96.18,58.42 R207.2
N21715202: length 4.3
  BOTTOM w0.2: T202.1 95.99,60.45 96.68,59.76 U201.15
N21715204: length 1.6
  BOTTOM w0.3: U201.16 97.18,58.32 C220.2
N21715315: length 1.3
  BOTTOM w0.4: C221.2 R208.2
N21715405: length 22.8
  TOP w0.5: 111,31.45 111,28 ; 111,31.45 v1(110.7,31.45) v1(110.7,30.85) ; 111,31.45 v1(111.3,31.45) v1(111.3,30.85) ; 111,28 110.7,28.3 v1(110.7,30.85) ; 111,28 111.3,27.7 ; v1(110.7,30.85) v1(111.3,30.85) ; v1(111.3,30.85) 111.3,27.7 ; 111.3,27.7 112.4,26.6
  BOTTOM w2: 110.4,26.9 112.2,26.9 115.6,23.5 J803.4
N21715413: length 28
  TOP w0.5: 111,32.75 v1(111.3,32.75) v1(111.3,33.35) 111.3,36.3 111.2,36.4 ; 111,32.75 111,36.2 ; 111,32.75 v1(110.7,32.75) v1(110.7,33.35) 110.7,35.9 111,36.2 ; 111.2,36.4 111,36.2 ; 111.2,36.4 112.4,37.6
  BOTTOM w2: 110.6,37 113.9,33.7 113.9,28.6 116.5,26 J803.3
N21715441: length 40.2
  TOP w0.4: L203.1 L213.1
  TOP w0.5: 101.65,23.45 101.65,25.25 ; 101.65,23.45 v1(101.35,23.45) v1(101.35,24.05) ; 101.65,23.45 v1(101.95,23.45) v1(101.95,24.05) ; 101.65,25.25 101.95,25.55 ; 101.65,25.25 101.35,24.95 v1(101.35,24.05) ; 101.95,25.55 103,26.6 ; 101.95,25.55 v1(101.95,24.05) ; v1(101.35,24.05) v1(101.95,24.05)
  BOTTOM w0.3: C234.1 101.78,29.86 U202.30 ; C225.2 97.68,26.8 97.95,27.07 97.95,28.55 98.18,28.78 U202.33
  BOTTOM w0.5: R213.2 97.8,24.8 101,24.8 101.35,24.45 ; R213.2 97.34,25.26 C225.2 ; R213.2 97.8,25.1 101.06,25.1 ; R217.1 101.95,27.66 101.95,25.63 ; R217.1 101.77,25.81 ; R217.1 101.77,29.79 C234.1 ; v1(101.95,24.05) 101.95,25.63 ; v1(101.95,24.05) v1(101.95,23.45) 101.65,23.45 ; v1(101.95,24.05) v1(101.35,24.05) ; 101.95,25.63 101.77,25.81 ; 101.77,25.81 101.65,25.69 ; 101.65,25.69 101.65,23.45 ; 101.65,25.69 101.06,25.1 ; 101.65,23.45 v1(101.35,23.45) v1(101.35,24.05) ; v1(101.35,24.05) 101.35,24.45 ; 101.35,24.45 101.35,24.81 101.06,25.1
N21715461: length 5.8
  BOTTOM w0.2: U202.38 95.68,28.2 95.4,27.92 95.4,26.16 C253.2 R229.2
N21715523: length 1.5
  BOTTOM w0.5: C228.2 R213.1
N21715527: length 1.6
  BOTTOM w0.3: U202.35 97.18,27.86 C225.1
N21715561: length 1.5
  BOTTOM w0.2: R214.1 96.18,27.76 U202.37
N21715623: length 1.3
  BOTTOM w0.5: R217.2 C229.2
N21715647: length 1.6
  BOTTOM w0.3: C232.2 92.59,30.36 U202.2
N21715792: length 2
  BOTTOM w0.3: U202.28 101.68,30.86 C234.2
N21715808: length 3.4
  BOTTOM w0.3: C235.1 102.87,31.36 U202.27
N21715856: length 1.7
  BOTTOM w0.3: C242.1 92.4,32.36 U202.6
N21715880: length 3.4
  BOTTOM w0.3: C238.1 102.88,32.86 U202.24
N21715898: length 2
  BOTTOM w0.3: C239.2 101.69,33.36 U202.23
N21715900: length 40.9
  TOP w0.4: L214.1 L204.1
  TOP w0.5: 101.65,38.95 101.35,39.25 v1(101.35,40.16) v1(101.35,40.76) 101.65,40.76 ; 101.65,38.95 101.95,38.65 ; 101.65,38.95 101.65,40.76 ; 101.65,40.76 v1(101.95,40.76) v1(101.95,40.16) 101.95,38.65 ; 101.95,38.65 103,37.6
  BOTTOM w0.3: C244.1 97.67,37.43 97.95,37.15 97.95,35.65 98.18,35.42 U202.18 ; C239.1 101.79,34.36 U202.21
  BOTTOM w0.5: 101.65,38.52 101.06,39.11 ; 101.65,38.52 101.65,40.76 ; 101.65,38.52 101.77,38.4 ; 101.06,39.11 101.02,39.15 ; 101.06,39.11 101.35,39.4 ; 100.72,39.45 101.3,39.45 101.35,39.4 ; 100.72,39.45 101.02,39.15 ; 100.72,39.45 100.64,39.45 ; v1(101.95,40.16) 101.95,38.58 ; v1(101.95,40.16) v1(101.35,40.16) ; v1(101.95,40.16) v1(101.95,40.76) 101.65,40.76 ; 101.95,38.58 101.77,38.4 ; 101.95,38.58 101.95,36.55 R222.2 ; 101.35,39.4 v1(101.35,40.16) ; R222.2 101.77,34.42 C239.1 ; R222.2 101.77,38.4 ; v1(101.35,40.16) v1(101.35,40.76) 101.65,40.76 ; v1(101.35,40.16) 100.64,39.45 ; 101.02,39.15 97.75,39.15 R224.1 ; 100.64,39.45 97.9,39.45 R224.1 ; R224.1 97.34,38.89 C244.1
N21716032: length 1.3
  BOTTOM w0.5: R222.1 C243.2
N21716038: length 4.5
  BOTTOM w0.2: T203.1 95.4,38.11 95.4,36.3 95.68,36.02 U202.13
N21716040: length 1.5
  BOTTOM w0.2: R223.2 96.18,36.47 U202.14
N21716042: length 4.2
  BOTTOM w0.2: T204.1 96.55,38.59 96.55,37.95 96.68,37.82 U202.15
N21716044: length 1.6
  BOTTOM w0.3: C244.2 97.18,36.37 U202.16
N21716155: length 1.5
  BOTTOM w0.5: C245.2 R224.2
N21722582: length 41.8
  TOP w0.4: L311.1 L301.1
  TOP w0.5: 28.4,39.75 v1(28.7,39.75) v1(28.7,39.15) 28.7,38.23 28.4,37.93 ; 28.4,39.75 v1(28.1,39.75) v1(28.1,39.15) 28.1,37.63 ; 28.4,39.75 28.4,37.93 ; 28.1,37.63 27.05,36.58 ; 28.1,37.63 28.4,37.93
  BOTTOM w0.3: C302.2 32.37,36.4 32.1,36.13 32.1,34.65 31.87,34.42 U301.33 ; U301.30 28.27,33.34 C310.1
  BOTTOM w0.5: 28.4,39.75 28.4,37.85 ; 28.4,39.75 v1(28.1,39.75) v1(28.1,39.15) ; 28.4,39.75 v1(28.7,39.75) v1(28.7,39.15) ; 28.4,37.85 28.4,37.51 ; 28.4,37.85 29.2,38.65 ; 29.2,38.65 29.5,38.35 30.65,38.35 ; 29.2,38.65 v1(28.7,39.15) ; 32.71,37.44 32.05,38.1 30.4,38.1 ; 32.71,37.44 32.71,37.89 R302.2 32.25,38.35 30.65,38.35 ; 32.71,37.44 C302.2 ; 28.4,37.51 28.99,38.1 ; 28.4,37.51 28.28,37.39 ; 28.99,38.1 28.7,38.39 v1(28.7,39.15) ; 28.99,38.1 30.4,38.1 ; v1(28.7,39.15) v1(28.1,39.15) ; v1(28.1,39.15) 28.1,37.57 ; R303.1 28.1,35.54 28.1,37.57 ; R303.1 28.28,37.39 ; R303.1 28.28,33.41 C310.1 ; 28.28,37.39 28.1,37.57 ; 30.65,38.35 30.4,38.1
N21722605: length 5.8
  BOTTOM w0.2: U301.38 34.37,35 34.65,35.28 34.65,37.03 C349.2 36.84,38.14 R325.2
N21722669: length 1.5
  BOTTOM w0.5: C303.2 R302.1
N21722673: length 1.6
  BOTTOM w0.3: U301.35 32.87,35.34 C302.1
N21722707: length 1.5
  BOTTOM w0.2: U301.37 33.87,35.44 R301.1
N21722769: length 1.3
  BOTTOM w0.5: R303.2 C307.2
N21722793: length 1.6
  BOTTOM w0.3: U301.2 37.47,32.84 C308.2
N21722854: length 28.7
  TOP w0.5: 19,35.23 19.3,34.93 v1(19.3,32.35) v1(19.3,31.75) 19,31.75 ; 19,35.23 19,31.75 ; 19,35.23 18.7,35.53 ; 18.7,35.53 v1(18.7,32.35) v1(18.7,31.75) 19,31.75 ; 18.7,35.53 17.65,36.58
  BOTTOM w2: 19.15,33.95 17.75,33.95 17,33.2 17,26.75 13.1,22.85 J804.1
N21722936: length 2
  BOTTOM w0.3: C310.2 28.37,32.34 U301.28
N21722954: length 3.4
  BOTTOM w0.3: U301.27 27.18,31.84 C311.1
N21722998: length 1.7
  BOTTOM w0.3: U301.6 37.65,30.84 C318.1
N21723019: length 3.4
  BOTTOM w0.3: U301.24 27.18,30.34 C314.1
N21723033: length 31.9
  TOP w0.5: 19,30.45 v1(18.7,30.45) v1(18.7,29.85) 18.7,26.65 ; 19,30.45 v1(19.3,30.45) v1(19.3,29.85) 19.3,27.25 19,26.95 ; 19,30.45 19,26.95 ; 19,26.95 18.7,26.65 ; 18.7,26.65 17.65,25.6
  BOTTOM w2: 19.62,25.57 14.25,20.2 11.05,20.2 9.6,21.65 9.6,24.2 10.75,25.35 J804.2
N21723038: length 2
  BOTTOM w0.3: U301.23 28.37,29.84 C315.2
N21723040: length 40.9
  TOP w0.4: L302.1 L312.1
  TOP w0.5: 28.1,24.55 28.4,24.25 ; 28.1,24.55 27.05,25.6 ; 28.1,24.55 v1(28.1,23.03) v1(28.1,22.43) 28.4,22.43 ; 28.4,24.25 28.4,22.43 ; 28.4,24.25 28.7,23.95 v1(28.7,23.03) v1(28.7,22.43) 28.4,22.43
  BOTTOM w0.3: C315.1 28.27,28.84 U301.21 ; U301.18 31.87,27.73 32.1,27.5 32.1,26.05 32.39,25.76 C320.1
  BOTTOM w0.5: 28.4,23.03 v1(28.1,23.03) ; 28.4,23.03 v1(28.7,23.03) ; 28.4,23.03 28.4,24 ; v1(28.1,23.03) 28.1,24.61 ; v1(28.1,23.03) v1(28.1,22.43) ; 28.1,24.61 28.1,26.64 R306.2 ; 28.1,24.61 28.28,24.79 ; v1(28.1,22.43) v1(28.7,22.43) v1(28.7,23.03) ; v1(28.1,22.43) v1(28.7,23.03) ; R306.2 28.28,24.79 ; R306.2 28.24,26.86 C315.1 ; 28.28,24.79 28.4,24.67 ; 29.27,23.8 32.35,23.8 R308.1 32.71,24.31 32.71,24.74 ; 29.27,23.8 29.55,24.08 ; 29.27,23.8 29.13,23.66 ; 32.71,24.74 C320.1 ; 32.71,24.74 32.05,24.08 29.55,24.08 ; 28.4,24 28.4,24.67 ; 28.4,24 28.74,23.66 29.13,23.66 ; 28.4,24.67 28.99,24.08 29.55,24.08 ; v1(28.7,23.03) 28.7,23.23 29.13,23.66
N21723161: length 1.3
  BOTTOM w0.5: R306.1 C319.2
N21723167: length 4.5
  BOTTOM w0.2: U301.13 34.37,27.18 34.65,26.9 34.65,25.08 T301.1
N21723169: length 1.6
  BOTTOM w0.2: R307.2 33.87,26.72 U301.14
N21723171: length 4.2
  BOTTOM w0.2: U301.15 33.37,25.38 33.5,25.25 33.5,24.6 T302.1
N21723173: length 1.6
  BOTTOM w0.3: U301.16 32.87,26.82 C320.2
N21723285: length 1.5
  BOTTOM w0.5: C321.2 R308.2
N21723451: length 39.8
  TOP w0.5: 17.65,58.52 18.7,57.47 ; 18.7,57.47 v1(18.7,54.3) v1(18.7,53.7) 19,53.7 ; 18.7,57.47 19,57.17 ; 19,53.7 v1(19.3,53.7) v1(19.3,54.3) 19.3,56.87 19,57.17 ; 19,53.7 19,57.17
  BOTTOM w2: 17.9,54.4 12.2,48.7 J804.4
N21723475: length 43
  TOP w0.4: L304.2 L314.2
  TOP w0.5: 19,52.4 v1(19.3,52.4) v1(19.3,51.8) 19.3,49.2 19,48.9 ; 19,52.4 v1(18.7,52.4) v1(18.7,51.8) 18.7,48.6 ; 19,52.4 19,48.9 ; 19,48.9 18.7,48.6 ; 18.7,48.6 17.65,47.55
  BOTTOM w2: 19.7,50.25 17.45,50.25 14.6,47.4 14.6,28.95 13.5,27.85 J804.3
N21723494: length 41.9
  TOP w0.4: L303.1 L313.1
  TOP w0.5: 28.1,59.57 28.4,59.87 ; 28.1,59.57 27.05,58.52 ; 28.1,59.57 v1(28.1,61.1) v1(28.1,61.7) 28.4,61.7 ; 28.4,59.87 28.7,60.17 v1(28.7,61.1) v1(28.7,61.7) 28.4,61.7 ; 28.4,59.87 28.4,61.7
  BOTTOM w0.3: C325.2 32.37,58.35 32.1,58.08 32.1,56.65 31.87,56.42 U302.33 ; C334.1 28.26,55.29 U302.30
  BOTTOM w0.5: R317.1 28.1,57.48 28.1,59.52 ; R317.1 28.28,55.35 C334.1 ; R317.1 28.28,59.33 ; v1(28.1,61.1) v1(28.1,61.7) 28.4,61.7 ; v1(28.1,61.1) 28.1,59.52 ; v1(28.1,61.1) v1(28.7,61.1) ; 30.4,60.3 29.5,60.3 29.04,60.76 ; 30.4,60.3 30.1,60 ; 30.4,60.3 32.45,60.3 R313.2 32.71,59.89 32.71,59.39 ; 28.28,59.33 28.4,59.45 28.4,61.7 ; 28.28,59.33 28.28,59.34 ; 28.99,60.05 28.28,59.34 ; 28.99,60.05 29.04,60 ; 28.99,60.05 28.7,60.34 v1(28.7,61.1) ; 28.28,59.34 28.1,59.52 ; 28.4,61.7 v1(28.7,61.7) v1(28.7,61.1) ; 30.1,60 29.04,60 ; 30.1,60 32.1,60 32.71,59.39 ; 32.71,59.39 C325.2 ; 29.04,60.76 v1(28.7,61.1) ; 29.04,60.76 29.04,60
N21723515: length 5.8
  BOTTOM w0.2: U302.38 34.37,56.95 34.65,57.23 34.65,58.98 C351.2 35.77,60.1 R327.2
N21723601: length 1.6
  BOTTOM w0.5: C328.2 R313.1
N21723605: length 1.6
  BOTTOM w0.3: C325.1 32.87,57.29 U302.35
N21723639: length 1.5
  BOTTOM w0.2: R314.1 33.87,57.39 U302.37
N21723713: length 1.3
  BOTTOM w0.5: C329.2 R317.2
N21723762: length 1.6
  BOTTOM w0.3: C332.2 37.48,54.79 U302.2
N21723903: length 2
  BOTTOM w0.3: C334.2 28.36,54.29 U302.28
N21723921: length 3.4
  BOTTOM w0.3: U302.27 27.17,53.79 C335.1
N21723965: length 1.7
  BOTTOM w0.3: U302.6 37.66,52.79 C342.1
N21723986: length 3.4
  BOTTOM w0.3: U302.24 27.18,52.29 C338.1
N21724005: length 2
  BOTTOM w0.3: C339.2 28.37,51.79 U302.23
N21724007: length 36.9
  TOP w0.4: L304.1 L314.1
  TOP w0.5: 28.4,44.38 28.4,46.2 ; 28.4,44.38 v1(28.7,44.38) v1(28.7,44.98) 28.7,45.9 28.4,46.2 ; 28.4,44.38 v1(28.1,44.38) v1(28.1,44.98) 28.1,46.5 ; 28.4,46.2 28.1,46.5 ; 27.05,47.55 28.1,46.5
  BOTTOM w0.3: C339.1 28.27,50.79 U302.21 ; C344.1 32.54,47.71 32.1,48.15 32.1,49.45 31.87,49.68 U302.18
  BOTTOM w0.5: C339.1 28.28,50.72 R322.2 28.28,46.74 ; 28.28,46.74 28.4,46.62 ; 28.28,46.74 28.1,46.56 v1(28.1,44.98) ; 28.4,46.62 28.4,44.38 ; 28.4,46.62 28.99,46.03 ; R324.1 32.2,45.75 29.27,45.75 28.99,46.03 ; R324.1 32.71,46.26 C344.1 ; R324.1 32.2,46.05 29.01,46.05 28.99,46.03 ; 28.99,46.03 28.7,45.74 v1(28.7,44.98) ; 28.4,44.38 v1(28.1,44.38) v1(28.1,44.98) ; 28.4,44.38 v1(28.7,44.38) v1(28.7,44.98) ; v1(28.7,44.98) v1(28.1,44.98)
N21724126: length 1.3
  BOTTOM w0.5: R322.1 C343.2
N21724132: length 4.5
  BOTTOM w0.2: U302.13 34.37,49.13 34.65,48.85 34.65,47.03 T303.1
N21724134: length 1.6
  BOTTOM w0.2: R323.2 33.87,48.67 U302.14
N21724136: length 4.2
  BOTTOM w0.2: T304.1 33.5,46.55 33.5,47.2 33.37,47.33 U302.15
N21724138: length 1.6
  BOTTOM w0.3: C344.2 32.87,48.77 U302.16
N21724244: length 1.5
  BOTTOM w0.5: C345.2 R324.2
N21729503: length 2.2
  TOP w0.25: C11.2 25.75,4.35 26.45,3.65 U2.7
N21729694: length 3.4
  TOP w0.25: v1(26.8,4.2) 26.85,4.15 U2.6
  BOTTOM w0.1: R3.2 R2.1 v1(26.8,4.2) R1.1
N21735247: length 1.8
  TOP w0.1: UNK4U9.K2 v1(46.45,43.6)
  BOTTOM w0.1: UNK4C26.2 v1(46.45,43.6)
N21735401: length 1.8
  TOP w0.1: UNK4U9.R5 v1(48.5,41.1)
  BOTTOM w0.1: v1(48.5,41.1) 48.3,40.9 UNK4R17.2
N21775203: length 4.5
  BOTTOM w0.1: J813.1 93.68,8.3 93.53,8.46 93.53,9.38 93.05,9.85 92.44,9.85 91.67,10.61 91.67,10.88 92.05,11.25 UNK5R71.1
N21775223: length 4.5
  BOTTOM w0.1: J813.2 93.18,8.3 93.3,8.42 93.3,9.28 92.96,9.62 92.34,9.62 91.45,10.52 91.45,10.85 91.05,11.25 UNK5R72.1
N21775243: length 4.5
  BOTTOM w0.1: UNK5R73.1 89.6,10.8 90.65,9.75 91.2,9.75 92.18,8.77 J813.4
N21775263: length 4.8
  BOTTOM w0.1: J813.5 91.68,8.67 90.9,9.45 90.55,9.45 88.95,11.05 88.7,11.05 UNK5R74.1
N21775283: length 8
  BOTTOM w0.1: J813.6 91.18,8.52 88.9,10.8 88.15,10.8 88,10.95 88,13.5 88.5,14 UNK5R75.1
N21778072: length 4.2
  TOP w0.102: T109.1 65.22,53.68 66.34,52.56 66.34,51.41 66.24,51.31 U1.A4
N21778081: length 6.5
  TOP w0.102: U1.B5 66.56,50.45 66.56,52.66 65.78,53.44 65.78,55.32 65.23,55.88 T110.1
N21778090: length 8.4
  TOP w0.1: U1.B2 64.94,50.29 64.61,50.62 64.61,51.11 62.89,52.83 62.89,56.49 T111.1
N21778099: length 9.4
  TOP w0.1: U1.A2 64.92,50.79 64.92,51.12 63.09,52.95 63.09,58.21 62.58,58.72 T112.1
N21778148: length 10.2
  TOP w0.102: T113.1 64.05,59.8 64.05,53.8 65.58,52.28 65.58,50.78 U1.A3
N21778157: length 11.3
  TOP w0.1: U1.B3 65.26,50.45 65.26,51.09 63.29,53.06 63.29,58.81 T114.1
N21778166: length 6
  TOP w0.1: U1.A1 64.29,51.13 62.68,52.73 62.68,55.28 T115.1
N21778175: length 6.9
  TOP w0.1: U1.C3 65.27,49.79 64.85,49.79 64.61,50.02 64.61,50.22 64.39,50.45 64.11,50.45 63.93,50.62 63.93,51.18 62.48,52.63 62.48,54.06 T116.1
N21778255: length 6.4
  TOP w0.1: T120.1 70.23,55.73 70.23,51.12 70.47,50.88 70.47,50.45 U1.B10
N21800110: length 28.6
  BOTTOM w0.1: R226.1 R225.1 87.15,64.05 82.35,64.05 81.85,64.55 81.85,68.95 79.9,70.9 72.9,70.9 71.5,69.5 68.45,69.5 67.53,68.58
  BOTTOM w0.3: 67.53,68.58 T310.1
N21860313: length 4.5
  BOTTOM w0.2: U201.8 91.89,55.3 91.24,55.95 C252.2 91.23,56.25 R228.2
N21864534: length 4.5
  BOTTOM w0.2: U202.8 91.89,33.36 91.24,34.01 C254.2 R230.2
N21877006: length 4.5
  BOTTOM w0.2: R326.2 C350.2 38.81,29.19 38.16,29.84 U301.8
N21880362: length 4.5
  BOTTOM w0.2: U302.8 38.16,51.79 38.81,51.14 C352.2 39.94,50.84 R328.2
N21888872: length 4.1
  BOTTOM w0.2: Q3.3 37.55,13.25 R16.2 R17.2
N21888995: length 6.2
  BOTTOM w0.2: Q2.3 39.6,5.85 40.85,5.85 R18.2 R19.2
N21888998: length 1.6
  BOTTOM w0.2: Q2.1 R16.1
N21889394: length 1.5
  BOTTOM w0.2: R15.1 Q3.1
N21890397: length 3.9
  BOTTOM w0.1: Q4.3 86.55,30.5 R329.2 R332.2
N21890399: length 2.5
  BOTTOM w0.1: R330.2 R331.2 81.25,30.2 Q5.3
N21890429: length 2.3
  BOTTOM w0.1: Q5.1 83.75,27.85 R332.1
N21890459: length 1.5
  BOTTOM w0.2: Q4.1 87.85,27.75 R333.1
N21892603: length 12.3
  TOP w0.1: v1(84.75,48.8) 84.4,48.45 82.9,48.45 82.3,47.85 79,47.85 78.65,47.5 78.15,47.5 77.9,47.75 74.98,47.75 74.93,47.81 74.93,47.83 74.35,47.83 U1.F16
  BOTTOM w0.1: v1(84.75,48.8) 85.2,48.8 R103.1
N21892620: length 13
  TOP w0.102: v2(73.72,47.85) U1.F15
  BOTTOM w0.1: v2(73.72,47.85) 73.9,47.85 74.49,48.44 79.84,48.44 80.8,49.4 84.85,49.4 R104.1
N21892674: length 8
  TOP w0.1: U1.H16 74.16,46.22 74.48,45.9 75.36,45.9 75.54,45.72 80.93,45.72 R107.1
N21892682: length 1.9
  TOP w0.1: U1.G17 76.48,46.87 R108.1
N21892690: length 5.8
  TOP w0.1: R109.1 79.4,47.1 77.95,47.1 77.75,47.3 75.7,47.3 75.6,47.2 74.37,47.2 U1.G16
N21892698: length 9.1
  TOP w0.1: U1.G14 v2(73.07,47.2)
  BOTTOM w0.1: v2(73.07,47.2) 73.36,47.49 73.87,47.49 74.62,48.24 80.91,48.24 R110.1
N22017810: length 20.7
  TOP w0.1: v1(95.1,17.7) 94.88,17.48 94.88,17.17 94.35,16.65 93.15,16.65 92.7,16.2 UNK5R84.1
  BOTTOM w0.1: J814.2 102.1,5.3 101.88,5.52 101.88,7.31 99.88,9.3 97.33,9.3 94.85,11.78 94.85,17.45 v1(95.1,17.7)
N22017884: length 25.2
  TOP w0.1: UNK5R83.1 89.85,18.45 93.6,18.45 94.3,19.15 v1(95,19.15)
  BOTTOM w0.1: J814.4 100.8,7.2 99.45,8.55 96.95,8.55 93.95,11.55 93.95,18.75 94.35,19.15 v1(95,19.15)
N22060831: length 20.3
  TOP w0.1: UNK5R85.1 92.7,17.3 93.13,16.88 94.26,16.88 94.65,17.27 94.65,17.45 v1(94.4,17.7)
  BOTTOM w0.1: J814.3 101.45,5.3 101.65,5.5 101.65,7.21 99.79,9.07 97.24,9.07 94.62,11.69 94.62,17.48 v1(94.4,17.7)

## Copper pours and planes (outline as drawn)
GND on TOP: 8.5,0.5 7.44,0.94 7,2 7,61.75 7.44,62.81 8.5,63.25 10.5,63.25 15.27,65.23 17.25,70 17.25,74 17.4,74.35 17.75,74.5 91.75,74.5 92.1,74.35 92.25,74 92.25,70 95.71,64.1 102.55,64.26 102.55,63 104.5,63 104.5,64.75 103.24,64.75 104.98,66.87 105.73,69.5 105.75,69.5 105.75,74 105.9,74.35 106.25,74.5 121.5,74.5 122.56,74.06 123,73 123,23 122.56,21.94 121.5,21.5 107.5,21.5 106.44,21.06 106,20 106,2 105.56,0.94 104.5,0.5 83.75,0.5 83.4,0.65 83.25,1 83.25,4.5 76.5,11.25 69.75,4.5 69.75,1 69.6,0.65 69.25,0.5 ; 20 cut-outs
VCC5V on TOP: 38.1,12.2 24.95,12.2 24.95,14.3 25.2,14.55 38.55,14.55 41.15,11.95 41.15,8.7 41,8.55 39.4,8.55 39.25,8.7 39.25,11.05
VCC5V on BOTTOM: 51.2,10.5 51.2,9.25 51.35,9.1 52.75,9.1 54.2,10.55 55.15,10.55 55.15,11 55.1,11.05 53.85,11.05 53.7,11.2 51.9,11.2
VCC5V on BOTTOM: 40,8.75 40,11 40.2,11.2 43.5,11.2 43.65,11.05 45.3,11.05 45.3,10.55 44.9,10.55 42.95,8.6 40.15,8.6
VCC5V on MID2(L3): 40,10.2 40,8.6 40.2,8.4 62.85,8.4 63.05,8.6 63.05,10.2
VCC_3.3V on MID2(L3): 44.55,28.2 44.3,28.45 44.3,29.35 51.05,36.1 51.05,38.85 49.25,40.65 49.25,42.25 49.35,42.35 50.05,42.35 50.55,42.85 50.55,45.3 48.95,46.9 48.95,54.7 45.2,58.45 45.2,59.2 45.35,59.35 54.9,59.35 56.85,57.4 61,57.4 61.8,56.6 68.9,56.6 69.85,57.55 74.3,57.55 76.2,55.65 84.05,55.65 85.45,54.25 85.45,53.85 56.2,53.85 54.5,52.15 54.5,31.25 51.45,28.2
VDD_EE on TOP: 44.5,20.4 44.5,18.2 48.9,18.2 49.45,17.65 49.45,15.95 50,15.4 51.05,15.4 51.15,15.5 51.15,21.15 50.9,21.4 45.5,21.4
VDD_EE on MID2(L3): 50.05,15.55 50.05,26.35 54.75,31.05 54.75,43.7 57.05,46 58.5,46 58.65,45.85 58.65,43.9 57,42.25 57,30.1 51.75,24.85 51.75,15.4 50.2,15.4
VDDAO_3.3V on BOTTOM: 49.3,21.4 49.7,21 49.7,18.7 44.1,18.7 43.9,18.5 43.9,15.6 43.7,15.4 42.7,15.4 42.45,15.65 42.45,21.1 42.75,21.4
VDDAO_3.3V on MID2(L3): 41.8,15.4 41.6,15.6 41.6,19.35 36.15,24.8 33.85,24.8 33.7,24.95 33.7,25.25 33.9,25.45 38.75,25.45 40.3,27 40.3,31.1 36.3,35.1 36.3,36 37.75,37.45 37.75,42.85 33.6,47 33.6,47.4 36.55,50.35 36.55,56.05 33.7,58.9 33.7,60.8 35.35,62.45 85.5,62.45 89.35,58.6 92.7,58.6 92.95,58.35 92.95,57.5 92.2,56.75 85.85,56.75 84.6,58 70.95,58 70.7,57.75 62.5,57.75 61.9,58.35 61.05,58.35 60.5,57.8 57.1,57.8 55.05,59.85 42.8,59.85 41.85,58.9 41.85,37.25 43.6,35.5 43.6,34.6 42.4,33.4 42.4,27.05 43.8,25.65 43.8,15.4
VDDCPU on BOTTOM (solid shape): 58.9,50.8 58.9,48.54 59.59,47.85 62.13,47.85 62.38,47.6 62.38,46.39 58.89,46.39 57.2,48.08 57.2,50.8 57.35,50.95 58.75,50.95
VDDCPU on BOTTOM: 59.6,20.6 59.6,18.5 55.2,18.5 54.64,17.94 54.65,15 54.45,14.8 53.1,14.8 52.95,14.95 52.94,21.1 53.24,21.4 58.8,21.4
VDDCPU on MID2(L3): 52.15,15.05 52.15,24.7 57.3,29.85 57.3,42.25 58.8,43.75 58.8,48.05 57.2,49.65 57.2,51 57.55,51.35 59.05,51.35 61.2,49.2 61.2,43.4 60.15,42.35 60.15,28.4 54.05,22.3 54.05,14.95 53.9,14.8 52.4,14.8
VDDQ1.35V on BOTTOM (solid shape): 63.95,39.57 62.09,37.71 60.56,37.71 60.25,38.02 60.25,39.27 60.5,39.52 62,39.52 63.95,41.48
VDDQ1.35V on TOP: 60.8,13.5 61.7,13.5 61.85,13.65 61.85,19.55 61.2,20.2 56.15,20.2 56.15,18.6 59.9,18.6 60.15,18.35 60.15,14.15
VDDQ1.35V on MID2(L3): 60.55,13.85 60.9,13.5 67.6,13.5 78.55,24.45 78.55,39.25 73.75,44.05 62.4,44.05 60.55,42.2
Net_121 on TOP, BOTTOM, MID1(L2), MID2(L3): 128,151.5 129.06,151.06 129.5,150 129.5,2 129.06,0.94 128,0.5 127.75,0.5 110.5,0.5 109.44,0.94 109,2 109,18.5 121.5,18.5 124.68,19.82 126,23 126,150 126.44,151.06 127.5,151.5
Net_121 on TOP, BOTTOM, MID1(L2), MID2(L3): 2,0.5 0.94,0.94 0.5,2 0.5,150 0.94,151.06 2,151.5 2.25,151.5 19.5,151.5 20.56,151.06 21,150 21,133.5 8.5,133.5 5.32,132.18 4,129 4,2 3.56,0.94 2.5,0.5
PWR_24V on TOP: 54.1,67.75 54.1,63.25 44.3,63.25 44.3,67.75 45.65,69.1 52.75,69.1
PWR_24V on TOP: 85.05,13.45 85.05,12.85 87.6,10.3 87.6,7.2 84,7.2 84,8.15 80.9,11.25 80.9,13.3 81.05,13.45
PWR_24V on TOP: 29.3,3.6 29.3,3.75 64.2,3.75 66.35,5.9 67.75,5.9 67.9,5.75 67.9,4.3 65.1,1.5 31.4,1.5
PWR_24V on TOP: 75.2,67.2 75.2,63.7 75.8,63.1 86.6,63.1 87.2,63.7 87.2,67.2 86.6,67.8 75.8,67.8
PWR_24V on BOTTOM: 32,1.9 30.9,3 30.9,10.4 27.1,14.2 24,14.2 23.5,14.7 23.5,17.3 23.65,17.45 28.3,17.45 33.7,12.05 33.7,4.6 34.25,4.05 40.05,4.05 40.2,3.9 40.2,2.05 40.05,1.9
PWR_24V on BOTTOM: 65.5,3.85 65.3,4.05 65.3,8.6 71.05,14.35 79.35,14.35 80.35,15.35 80.35,22.4 83.05,25.1 90.05,25.1 92.55,22.6 95.55,22.6 96.3,21.85 98.95,21.85 99.15,21.65 99.15,20.25 99,20.1 95.65,20.1 94.85,20.9 91.9,20.9 89.5,23.3 84.3,23.3 82.6,21.6 82.6,11.2 82.5,11.1 80.95,11.1 80.25,11.8 72.6,11.8 67.95,7.15 67.95,4.05 67.75,3.85
PWR_24V on MID2(L3): 23.25,16.65 23.25,22.15 24.45,23.35 24.45,62.1 31.6,69.25 50.85,69.25 51.15,68.95 51.15,63.75 50.95,63.55 34.6,63.55 32.75,61.7 32.75,21.55 27.5,16.3 23.6,16.3
PWR_24V on MID2(L3): 97.4,20.3 97.4,55.5 93,59.9 89.25,59.9 85.75,63.4 78.1,63.4 77.7,63.8 77.7,67.15 78.3,67.75 90.8,67.75 96.55,62 101.35,62 104.75,58.6 104.75,20.85 104,20.1 97.6,20.1
N21492258 on BOTTOM: 59.5,17.3 59.5,15.66 57.59,13.75 57.59,12.1 56.99,11.5 56,11.5 56,14.8 55.25,15.55 55.25,17.3
N21499562 on TOP: 48.1,11.5 48.1,14.2 48.85,14.95 48.85,17 44.55,17 44.55,15.95 46.5,14 46.5,12.1 47.1,11.5
N21500929 on TOP: 58.8,11.5 58.8,16.45 58.75,16.5 56.25,16.5 56.25,14.95 57.2,14 57.2,12.1 57.8,11.5
N21504675 on TOP: 28.25,4.85 27.9,5.2 27.9,6.5 27.1,7.3 24.95,7.3 24.95,9.4 30.65,9.4 30.65,7.05 28.45,4.85
N21506095 on BOTTOM: 49.6,17.1 49.6,15.2 48.55,15.2 47.1,13.75 47.1,12.1 46.5,11.5 45.5,11.5 45.5,14.6 44.2,15.9 44.2,17.1
N21714583 on TOP: 101.25,45.15 104.1,45.15 104.25,45.3 104.25,50.35 104.1,50.5 101.25,50.5 101.1,50.35 101.1,45.3
N21714864 on TOP: 110.6,46.7 114.1,46.7 114.25,46.85 114.25,53.55 114.1,53.7 110.6,53.7 110.45,53.55 110.45,46.85
N21714864 on BOTTOM: 111.55,47.85 108.95,47.85 108.95,53.7 111.4,53.7 111.55,53.55
N21715052 on TOP: 110.6,54.5 114.1,54.5 114.25,54.65 114.25,61.35 114.1,61.5 110.6,61.5 110.45,61.35 110.45,54.65
N21715052 on BOTTOM: 113.6,56.55 111.7,56.55 111.35,56.2 108.95,56.2 108.95,54.5 112.8,54.5 113.6,55.3
N21715058 on TOP: 101.25,57.7 104.1,57.7 104.25,57.85 104.25,62.95 104.1,63.1 101.25,63.1 101.1,62.95 101.1,57.85
N21715405 on TOP: 110.6,24.7 114.1,24.7 114.25,24.85 114.25,31.55 114.1,31.7 110.6,31.7 110.45,31.55 110.45,24.85
N21715405 on BOTTOM: 111.55,25.9 109.15,25.9 109.15,31.7 111.4,31.7 111.55,31.55
N21715413 on TOP: 110.6,32.5 114.1,32.5 114.25,32.65 114.25,39.35 114.1,39.5 110.6,39.5 110.45,39.35 110.45,32.65
N21715413 on BOTTOM: 109.1,32.5 109.1,38.3 110.7,38.3 112.4,36.6 112.4,34.4 111.7,34.4 111.55,34.25 111.55,32.65 111.4,32.5
N21715441 on TOP: 101.25,23.2 104.1,23.2 104.25,23.35 104.25,28.35 104.1,28.5 101.25,28.5 101.1,28.35 101.1,23.35
